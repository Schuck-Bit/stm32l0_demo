# Keil uVision project STM32L0xx.uvprojx, settings and files
target Project_Name (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ExecutableFile +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c misc: --gnu
  c include: ..\..\app;.\STM32L0xx_Cube\Drivers\CMSIS\Include;.\STM32L0xx_Cube\Drivers\CMSIS\Device\ST\STM32L0xx\Include;.\STM32L0xx_Cube\Drivers\STM32L0xx_HAL_Driver\Inc;.\STM32L0xx_Cube\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;.\STM32L0xx_Cube\Drivers\STM32L0xx_HAL_Driver\Src;.\drivers;..\STM32L0xx;..\..\module;..\..\os;..\..\app\user;.\STM32L0xx_Cube\Inc;..\..\example
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup Code
    ./STM32L0xx_Cube/MDK-ARM/: startup_stm32l051xx.s
  group CMSIS
    ./STM32L0xx_Cube/Src/: system_stm32l0xx.c
  group bsp
    ./drivers/: bsp.c stm32_led.c stm32_sleep.c stm32_usart.c
  group app
    ../../app/: main.c
    ./: config.h
  group Library
    ./STM32L0xx_Cube/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_gpio.c stm32l0xx_hal_rcc.c stm32l0xx_hal_uart.c stm32l0xx_hal_usart.c stm32l0xx_ll_rtc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_ll_rcc.c stm32l0xx_hal_dma.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rng.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_usb.c stm32l0xx_ll_utils.c
  group os
    ../../os/: cola_os.c cola_device.c cola_init.c
  group app/usr
    ../../app/user/: app.c
  group bsp_cube
    ./STM32L0xx_Cube/Src/: gpio.c rtc.c usart.c
  group example
    ../../example/1.app_gpio_toggle/: app_gpio_toggle.c
    ../../example/2.app_usart/: app_usart.c
